# Keil uVision project project.uvprojx, settings and files
target rt-thread (6220000::V6.22::ARMCLANG)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__, GD32F470, RT_USING_ARMLIBC
  c include: packages\esp-hosted-latest\esp-hosted\host\drivers\transport;..\..\..\..\libcpu\arm\cortex-m4;packages\esp-hosted-latest\porting\port\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;packages\esp-hosted-latest\esp-hosted\common\protobuf-c;packages\esp-hosted-latest\porting\components\esp_netif\include;packages\gd32-arm-series-latest\GD32F4xx\GD32F4xx_standard_peripheral\Include;..\..\..\..\components\drivers\wlan;..\..\..\..\components\libc\compilers\common\extension;packages\esp-hosted-latest\esp-hosted\host\drivers\mempool;..\..\..\..\components\net\sal\impl;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\esp-hosted-latest\porting\ota;packages\esp-hosted-latest\esp-hosted\host\drivers\rpc\slaveif;..\..\..\..\components\drivers\include;..\..\..\..\components\net\sal\include\socket;board\ports;packages\esp-hosted-latest\esp-hosted\host\api\include;..\..\..\..\components\libc\compilers\common\include;board;packages\esp-hosted-latest\porting\components\log;..\..\..\..\components\finsh;packages\gd32-arm-cmsis-latest\GD32F4xx;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;packages\esp-hosted-latest\esp-hosted\host;packages\esp-hosted-latest\esp-hosted\host\drivers\bt;..\..\..\..\components\drivers\include;packages\esp-hosted-latest\porting\components\esp_wifi\include;..\..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\libraries\gd32_drivers;packages\esp-hosted-latest\esp-hosted\host\drivers\virtual_serial_if;..\..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\..\libcpu\arm\common;packages\esp-hosted-latest\porting\components\utils;.;..\..\..\..\components\net\netdev\include;..\..\..\..\components\net\lwip\port;packages\esp-hosted-latest\esp-hosted\common\proto;..\..\..\..\components\libc\posix\ipc;applications;packages\esp-hosted-latest\esp-hosted\host\drivers\rpc\wrap;packages\gd32-arm-cmsis-latest\GD32F4xx\GD\GD32F4xx\Include;packages\esp-hosted-latest\esp-hosted\common\include;..\..\..\..\components\drivers\smp_call;packages\esp-hosted-latest\esp-hosted\host\utils;..\..\..\..\components\drivers\include;packages\esp-hosted-latest\esp-hosted\host\drivers\transport\spi;..\..\..\..\components\drivers\include;..\..\..\..\include;packages\esp-hosted-latest\esp-hosted\host\drivers\serial;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\net\sal\include;packages\esp-hosted-latest\esp-hosted\host\drivers\rpc\core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../../components/drivers/wlan/: dev_wlan.c dev_wlan_cfg.c dev_wlan_cmd.c dev_wlan_lwip.c dev_wlan_mgnt.c dev_wlan_prot.c dev_wlan_workqueue.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_spi.c drv_usart.c
  group esp-hosted
    packages/esp-hosted-latest/esp-hosted/host/api/src/: esp_hosted_api.c esp_wifi_weak.c
    packages/esp-hosted-latest/porting/port/source/: esp_hosted_config.c os_wrapper.c spi_wrapper.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/rpc/core/: rpc_req.c rpc_core.c rpc_rsp.c rpc_evt.c
    packages/esp-hosted-latest/esp-hosted/host/utils/: common.c util.c stats.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/rpc/wrap/: rpc_wrap.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/mempool/: mempool.c
    packages/esp-hosted-latest/esp-hosted/common/proto/: esp_hosted_rpc.pb-c.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/virtual_serial_if/: serial_if.c
    packages/esp-hosted-latest/esp-hosted/common/protobuf-c/protobuf-c/: protobuf-c.c
    packages/esp-hosted-latest/porting/ota/: esp_hosted_ota.c
    packages/esp-hosted-latest/porting/wlan/: esp_wlan.c
    packages/esp-hosted-latest/porting/components/log/: esp_log.c log_linked_list.c tag_log_level.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/rpc/slaveif/: rpc_slave_if.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/serial/: serial_drv.c serial_ll_if.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/transport/spi/: spi_drv.c
    packages/esp-hosted-latest/porting/bt/: vhci_drv.c
    packages/esp-hosted-latest/porting/components/esp_wifi_remote/: esp_wifi_remote_net.c
    packages/esp-hosted-latest/esp-hosted/host/drivers/transport/: transport_drv.c
  group Finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F4xx/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    packages/gd32-arm-cmsis-latest/GD32F4xx/GD/GD32F4xx/Source/: system_gd32f4xx.c
    packages/gd32-arm-series-latest/GD32F4xx/GD32F4xx_standard_peripheral/Source/: gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_usart.c
  group lwIP
    ../../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../components/net/sal/socket/: net_netdb.c
    ../../../../components/net/sal/src/: sal_socket.c
software components: CMSIS:CORE 6.1.0
